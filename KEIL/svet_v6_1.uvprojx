# Keil uVision project svet_v6_1.uvprojx, settings and files
target Svet_8_9_LM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: svet_v6_1 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\KEIL;.\CMSIS\inc;..\SOURCE\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ./CMSIS/src/: system_stm32f0xx.c
  group StartUp
    ./CMSIS/StartUp/: startup_stm32f030.s
  group Source
    ../SOURCE/src/: main.c setting.c light.c lightpwm.c rs485.c
